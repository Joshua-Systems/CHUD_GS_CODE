options:
  parameters:
    author: flat-sat-workbench
    generate_options: qt_gui
    id: GS_RX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2M
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '2000000'
    sf: '7'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 435e6
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
